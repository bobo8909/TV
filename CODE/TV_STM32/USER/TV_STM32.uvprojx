# Keil uVision project TV_STM32.uvprojx, settings and files
target TV_STM32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TV_STM32 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\CAN;..\APP;..\HARDWARE\Speed;..\HARDWARE\Driver_IO;..\HARDWARE\SPI;..\HARDWARE\AD5734R;..\HARDWARE\IWDG;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\EXTI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../APP/: CANrecv_task.c CANsend_task.c IO_task.c DAC_task.c ADC_task.c SpeedCal_task.c Encoder_task.c AngleSensor_task.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/AD5734R/: driver_ad5734r.c
    ../HARDWARE/SPI/: driver_spi.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/Driver_IO/: driver_IO.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/EXTI/: exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c
  group README
    ../: README.TXT
